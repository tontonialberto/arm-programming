# Keil uVision project etl-example.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: etl-example
  c flags: Optim=6 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wno-c++98-compat -Wno-old-style-cast
  c include: .\etl\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.cpp readme.txt
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
