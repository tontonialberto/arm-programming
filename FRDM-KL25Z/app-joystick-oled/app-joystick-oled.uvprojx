# Keil uVision project app-joystick-oled.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: app-joystick-oled
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\libs
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Application
    ./: main.c hw_init.h hw_init.c util.h util.c
  group Libraries
    ./libs/: delay.h I2C_Interface.h I2C_Master.h
    ./libs/SSD1306/: SSD1306.c SSD1306.h SSD1306_Digits_V0.c SSD1306_Digits_V0.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
